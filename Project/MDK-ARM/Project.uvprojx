# Keil uVision project Project.uvprojx, settings and files
target ECG3 (ARM-ADS)
  device: STM32F427IGHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ECG3Code
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER STM32F427xx HSE_VALUE=16000000 SEGGER_PRINTF
  c include: ..\Inc;..\..\Drivers\STM32F4xx_HAL_Driver\Src;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares\Third_Party\FatFs\src;..\..\Middlewares\Third_Party\FatFs\src\drivers;..\..\Drivers\HAL_MSP\TIM;..\..\Drivers\HAL_BSP\DISCO_EVAL_BOARD;..\..\Drivers\HAL_BSP\GPIO;..\..\Drivers\HAL_BSP\SD;..\..\Drivers\HAL_BSP\LED;..\..\Middlewares\Third_Party\SEGGER_RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: stm32f4xx_it.c main.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_spi.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal.c stm32f4xx_ll_sdmmc.c
  group Middlewares/FatFs/Core
    ../../Middlewares/Third_Party/FatFs/src/: ff.c ff_gen_drv.c diskio.c
  group Middlewares/FatFs/Driver
    ../../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Drivers/HAL_BSP
    ../../Drivers/HAL_BSP/SD/: stm32f4xx_hal_bsp_sd.c
    ../../Drivers/HAL_BSP/LED/: stm32f4xx_hal_bsp_led.c
  group Drivers/HAL_MSP
    ../../Drivers/HAL_MSP/TIM/: stm32f4xx_hal_msp_tim.c
  group Doc
    ../Doc/: version.txt readme.txt
  group Middlewares/SEGGER_RTT
    ../../Middlewares/Third_Party/SEGGER_RTT/RTT/: SEGGER_RTT_printf.c SEGGER_RTT.c
    ../../Middlewares/Third_Party/SEGGER_RTT/Syscalls/: SEGGER_RTT_Syscalls_KEIL.c
software components: CMSIS:CORE 5.0.0, Device:Startup 2.6.0
